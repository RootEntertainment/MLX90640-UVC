# Keil uVision project audio.uvprojx, settings and files
target audio (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: audio +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\user\inc;..\at32f403a_407_board;..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\usb\usbd_drivers\inc;..\usb\video;..\usb\audio;..\ejpeg;..\MLX\headers;..\i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../user/src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
  group bsp
    ../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group usbd_drivers
    ../usb/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../usb/video/: video_class.c video_desc.c
  group ejpeg
    ../ejpeg/: ejpeg.c
  group MLX
    ../MLX/functions/: MLX90640_API.c MLX90640_I2C_Driver.c
  group i2c
    ../i2c_application_library/: i2c_application.c
